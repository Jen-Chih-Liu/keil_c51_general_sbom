# Keil uVision project w78_std_8051.uvproj, settings and files
target Target 1 (MCS-51)
  device: W78E052D Nuvoton
  cpu: IRAM(0x00-0xFF) IROM(0x0000-0x1FFF) CLOCK(40000000)
  output: w78_std_8051 +hex
  AfterMake: python ..\tools\generate_c51_sbom.py --project-dir .
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./src/: STARTUP.A51 main.c
